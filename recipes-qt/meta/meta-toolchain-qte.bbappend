# add a custom target task to remove and add bpp3 packages
TOOLCHAIN_TARGET_TASK = "packagegroup-custom-qte-toolchain-target"
